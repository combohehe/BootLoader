# IAR project appEx_cc2430.ewp, settings and files
configuration RX (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\chipcon\CC2430.i51
  ICC8051.CCDefines: chip=2430; COMPLETE_APPLICATION; RX
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\LIBRARY\CC2430\CUL\INCLUDE; ..\..\..\LIBRARY\CC2430\HAL\INCLUDE; ..\..\..\LIBRARY\CC2430\EB\INCLUDE; ..\INCLUDE
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  A8051.ADefines: chip=2430
  XLINK.XclFile: C:\SPP-BT001.xcl
configuration TX (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: chip=2430; COMPLETE_APPLICATION
  XLINK.XclFile: E:\study\zg projects\shm\xcl\SPP-BT001.xcl
  group appEx
    ../source/: flash.c rf_test.c
  group cul
    ../../../Library/cc2430/CUL/source/: dmaAllocChannel.c dmaFreeChannel.c dmaFromRadio.c dmaInit.c dmaSetUpChannel.c dmaToRadio.c dmaToUart0.c radio.c spp.c
  group hal
    ../../../Library/cc2430/HAL/source/: rfConfig.c rfReceivePacket.c rfSendPacket.c rfSetRadioFrequency.c wait.c
